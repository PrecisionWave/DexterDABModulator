<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_lo_dac</value></param>
<param><key>value</key><value>204.8e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_rf</value></param>
<param><key>value</key><value>201.072</value></param>
<param><key>label</key><value>Freq RF [MHz[</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>174</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>240</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_dsp</value></param>
<param><key>value</key><value>-6.0</value></param>
<param><key>label</key><value>gain DSP dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ip</value></param>
<param><key>value</key><value>"192.168.1.76"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.048e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/media/share_pcw/andreas/SLO-10D_swp.iq</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>offset</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>iio_attr_sink</key>
<param><key>id</key><value>iio_attr_sink</value></param>
<param><key>attr_type</key><value>1</value></param>
<param><key>channel</key><value>"voltage0"</value></param>
<param><key>device</key><value>"dexter_dsp_tx"</value></param>
<param><key>output</key><value>True</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>uri</key><value>ip</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0_0_0_0</value></param>
<param><key>attr</key><value>"frequency0"</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(int(f_rf*1e6-f_lo_dac))</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0_0_0_0_0</value></param>
<param><key>attr</key><value>"gain0"</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(int(65530*10**(gain_dsp/20)))</value></param>
</block>
<block>
<key>iio_device_sink</key>
<param><key>id</key><value>iio_device_sink_0</value></param>
<param><key>buffer_size</key><value>2**18</value></param>
<param><key>channels</key><value>["voltage0","voltage1"]</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>device</key><value>ad9957_tx0</value></param>
<param><key>uri</key><value>ip</value></param>
<param><key>interpolation</key><value>1</value></param>
<param><key>device_phy</key><value>ad9957_tx0</value></param>
<param><key>params</key><value>[]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>f_rf*1e6</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>60</value></param>
<param><key>ymin</key><value>-40</value></param>
</block>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>iio_device_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>iio_device_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0_0_0_0</source_block_id><sink_block_id>iio_attr_sink</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0_0_0_0_0</source_block_id><sink_block_id>iio_attr_sink</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
</flow_graph>
